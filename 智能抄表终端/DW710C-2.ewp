# IAR project DW710C-2.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tpannl8n.h
  General.OGChipSelectEditMenu: STR711 ST STR711
  ICCARM.CCDiagSuppress: Pa082,Pe188
  ICCARM.CCIncludePath2: include\; 
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: linker\lnkarm_flash.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.r79
  ICCARM.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: DW710C-2.dep DW710C-2.ewd DW710C-2.ewp DW710C-2.eww
  group include
    include/: 71x_conf.h 71x_it.h 71x_lib.h 71x_map.h 71x_type.h bspi.h eic.h Extern_Var.h flash.h font.h Global_define.h gpio.h Key.h LCD.h LED.h LunXun.h manage_485_asset_addr.h pub_tool.h rccu.h read_dl.h rtc.h Spi_Flash.h Task_Flag.h tim.h uart.h wdg.h
  group linker
    linker/: lnkarm_flash.xcl lnkarm_ram.xcl
  group source
    source/: 71x_it.c 71x_lib.c bspi.c eic.c flash.c font.c gpio.c Key.c LCD.c LED.c LunXun.c main.c manage_485_asset_addr.c pub_tool.c rccu.c read_dl.c rtc.c Spi_Flash.c tim.c uart.c wdg.c
  group startup
    startup/: 71x_init.s 71x_vect.s
